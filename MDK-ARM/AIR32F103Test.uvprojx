# Keil uVision project AIR32F103Test.uvprojx, settings and files
target AIR32F103Test (6190000::V6.19::ARMCLANG)
  device: AIR32F103CB Generic
  pack: Keil.AIR32F103_DFP.1.1.7
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AIR32F103Test +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=1
  c define: USE_HAL_DRIVER,AIR32F103xB
  c include: ../Core/Inc;..\Drivers\AIR32F1xx_HAL_Driver\Inc;..\Drivers\AIR32F1xx_HAL_Driver\Inc\Legacy;..\Drivers\CMSIS\Device\AIR32F1xx\Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Application/MDK-ARM
    ../Core/Src/: startup_air32f10x.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c myPrintf.c air32f1xx_hal_msp.c air32f1xx_it.c
  group Drivers/air32f1xx_HAL_Driver
    ../Drivers/AIR32F1xx_HAL_Driver/Src/: air32f1xx_hal.c air32f1xx_hal_cortex.c air32f1xx_hal_crc.c air32f1xx_hal_dma.c air32f1xx_hal_exti.c air32f1xx_hal_flash.c air32f1xx_hal_flash_ex.c air32f1xx_hal_gpio.c air32f1xx_hal_gpio_ex.c air32f1xx_hal_hcd.c air32f1xx_hal_i2c.c air32f1xx_hal_i2s.c air32f1xx_hal_irda.c air32f1xx_hal_iwdg.c air32f1xx_hal_mmc.c air32f1xx_hal_pwr.c air32f1xx_hal_rcc.c air32f1xx_hal_rcc_ex.c air32f1xx_hal_rtc.c air32f1xx_hal_rtc_ex.c air32f1xx_hal_sd.c air32f1xx_hal_spi.c air32f1xx_hal_tim.c air32f1xx_hal_tim_ex.c air32f1xx_hal_uart.c air32f1xx_hal_usart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/AIR32F1xx/Source/: system_air32f1xx.c
software components: CMSIS:CORE 5.6.0
